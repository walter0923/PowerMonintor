<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PowerMonitor.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\test\test.ewp</path>
    </project>
    <batchBuild />
</workspace>
